# Keil uVision project MM32SPIN.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.6
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32SPIN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STEP_DEVICE
  c include: .\CMSIS;.\Lib;.\Startup;.\User;.\HardWare\USART;.\HardWare\NVIC;.\HardWare\PWM;.\HardWare\RCC;.\HardWare\ADC;.\HardWare\motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group User
    ./User/: main.c system_MM32SPIN2xx_p.c
  group HardWare
    ./HardWare/USART/: USART.C
    ./HardWare/NVIC/: NVIC.C
    ./HardWare/PWM/: PWM.C
    ./HardWare/RCC/: RCC.C
    ./HardWare/ADC/: ADC.C
  group Lib
    ./Lib/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Startup
    ./Startup/: startup_MM32SPIN2xx_p.s
