# Keil uVision project MM32F3270.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F3270 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STEP_DEVICE
  c include: .\CMSIS;.\Startup;.\User;.\HardWare\USART;.\Lib;.\User;.\HardWare\IIC;.\HardWare\MPU6050;.\HardWare\HMC5983;.\HardWare\systick;.\HardWare\kalman;.\HardWare\GPS;.\HardWare\vector;.\HardWare\PWM;.\HardWare\Timer;.\HardWare\Target;.\HardWare\DMA;.\HardWare\PID;.\HardWare\Out_In
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./Startup/: startup_mm32f327x_keil.s
  group HardWare
    ./HardWare/USART/: USART.C
    ./HardWare/IIC/: IIC.C
    ./HardWare/MPU6050/: MPU6050.C
    ./HardWare/HMC5983/: HMC5983.C
    ./HardWare/systick/: systick.c
    ./HardWare/kalman/: kalman.c
    ./HardWare/GPS/: GPS.C
    ./HardWare/vector/: vector.c
    ./HardWare/PWM/: PWM.C
    ./HardWare/Timer/: Timer.c
    ./HardWare/Target/: Target.c
    ./HardWare/DMA/: DMA.C
    ./HardWare/PID/: pid.c
    ./HardWare/Out_In/: Key.c
  group User
    ./User/: main.c system_mm32f327x.c
  group Lib
    ./Lib/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
